## dts/bindings/behaviors/zmk,behavior-pmw3610-setting.yaml
```yaml
description: PMW3610-MCK runtime setting behavior

compatible: "zmk,behavior-pmw3610-mck-setting"

include: one_param.yaml
```
